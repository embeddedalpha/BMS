File: Schematic/USB_PD.sch (KiCad schematic (older format))
At the start: 32 parts

Commit message: Add files via upload
Other:
- moved on the sheet: Q?, R?
