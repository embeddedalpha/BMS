File: Schematic/Balance _FETS.sch (KiCad schematic (older format))
At the start: 54 parts

Commit message: Add files via upload
Parts:
- gave numbers to parts that had none: 54
